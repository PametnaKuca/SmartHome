# Keil uVision project smart_house.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: smart_house
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, HSE_VALUE=8000000, PLL_M=4, PLL_P=8, PLL_N=192, STM32F411xE
  c include: .\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\Libraries\CMSIS\Include;.\FreeRTOS\include;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Include;.\Include\Functions;.\TM_STM32F4\include;.\FreeRTOS\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STM32F4XX
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_exti.c misc.c stm32f4xx_tim.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_spi.c stm32f4xx_flash.c
  group FreeRTOS
    ./FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group Main Source Group
    ./: main.c
    ./Source/: init.c
  group Include
    ./Include/: init.h main.h
    ./Include/Functions/: dht22.h functions.h step_motor.h package.h
  group Functions
    ./Source/Functions/: dht22.c functions.c step_motor.c package.c
  group TM_STM32F4
    ./TM_STM32F4/src/: gpio.c tm_stm32f4_am2301.c tm_stm32f4_button.c tm_stm32f4_delay.c tm_stm32f4_disco.c tm_stm32f4_general.c tm_stm32f4_hcsr04.c tm_stm32f4_id.c tm_stm32f4_library_template.c tm_stm32f4_mfrc522.c tm_stm32f4_pwm.c tm_stm32f4_rcc.c tm_stm32f4_stdio.c tm_stm32f4_string.c tm_stm32f4_timer_properties.c tm_stm32f4_rtc.c tm_stm32f4_spi.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.6.0
